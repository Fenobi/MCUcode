# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\smg;.\Public;.\App\xpt2046;.\User
  group App
    ./App/smg/: smg.c
    ./App/xpt2046/: xpt2046.c
  group Public
    ./Public/: public.c
  group User
    ./User/: main.c
