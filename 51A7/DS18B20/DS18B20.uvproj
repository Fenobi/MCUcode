# Keil uVision project DS18B20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: DS18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\EEPROM;.\App\iic;.\App\key;.\App\smg;.\App\ds18b20
  group App
    ./App/smg/: smg.c
    ./App/ds18b20/: ds18b20.c
  group User
    ./User/: main.c
  group Public
    ./Public/: public.c
