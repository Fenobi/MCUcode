# Keil uVision project EEPROM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: EEPROM +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\key;.\App\smg;.\App\iic;.\App\at24c02
  group User
    ./User/: main.c
  group Public
    ./Public/: public.c
  group App
    ./App/key/: key.c
    ./App/smg/: smg.c
    ./App/iic/: iic.c
    ./App/at24c02/: at24c02.c
