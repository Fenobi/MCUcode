# Keil uVision project 红外.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 红外 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\smg;.\App\ired
  group App
    ./App/smg/: smg.c
    ./App/ired/: ired.c
  group Public
    ./Public/: public.c
  group User
    ./User/: main.c
