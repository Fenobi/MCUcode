# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\User;.\APP
  group public
    ./Public/: ADC.c delay.c EEPROM.c Exti.c GPIO.c PCA.c Soft_UART.c timer.c USART.C
  group user
    ./User/: main.c
