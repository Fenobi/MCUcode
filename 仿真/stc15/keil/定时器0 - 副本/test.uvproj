# Keil uVision project test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP;.\Public;.\User
  group User
    ./: main.c
  group Public
    ./Public/: public.c
  group APP
    ./APP/: IIC_LCD12864.c DS1302.c
