# Keil uVision project DS1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: DS1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\smg;.\Public;.\App\ds1302
  group User
    ./User/: main.c
  group App
    ./App/smg/: smg.c
    ./App/ds1302/: ds1302.c
  group Public
    ./Public/: public.c
