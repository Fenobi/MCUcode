# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\pcf8591;.\Public;.\App\smg;.\App\iic;..\第十一届
  group user
    ./: iic.c main.c public.c e2prom.c pcf8591.c smg.c key.c
