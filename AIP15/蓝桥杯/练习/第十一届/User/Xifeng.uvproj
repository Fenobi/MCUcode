# Keil uVision project Xifeng.uvproj, settings and files
target Xifeng (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Xifeng +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\Driver
  group User
    ./: main.c
  group Driver
    ../Driver/: Init.c Key.c Led.c Seg.c Uart.c iic.c pcf8591.c public.c ds18b20.c
