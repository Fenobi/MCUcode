# Keil uVision project 第八届.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 第九届 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\ds18b20;.\App\ds1302;.\App\EEPROM;.\App\iic;.\App\key;.\App\smg;.\Public;.\App\BEED_JDQ
  group App
    ./App/ds18b20/: ds18b20.c
    ./App/ds1302/: ds1302.c
    ./App/EEPROM/: EEPROM.c
    ./App/iic/: iic.c
    ./App/key/: key.c
    ./App/smg/: smg.c
    ./App/BEED_JDQ/: Buzz_Relay.c
  group Public
    ./Public/: public.c
  group User
    ./User/: main.c
