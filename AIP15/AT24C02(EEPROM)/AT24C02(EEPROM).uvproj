# Keil uVision project AT24C02(EEPROM).uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: AT24C02(EEPROM) +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\App\EEPROM;.\App\iic;.\App\smg;.\App\key
  group App
    ./App/EEPROM/: EEPROM.c
    ./App/iic/: iic.c
    ./App/smg/: smg.c
    ./App/key/: key.c
  group Public
    ./Public/: public.c
  group User
    ./User/: main.c
