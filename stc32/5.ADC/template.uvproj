# Keil uVision project template.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: template +hex
  group User
    ./User/: main.c
  group App
    ./App/ADC/: ADC.c
  group Public
    ./Public/: public.c time.c uart.c
